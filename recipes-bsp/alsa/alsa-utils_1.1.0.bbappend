FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-DMS-SE23-Add-a-dummy-before-first-chunk-for-touch-so.patch\
          "
